# Keil uVision project freertos_project.uvproj, settings and files
target freertos_project (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_project +hex
  AfterMake: fromelf --bin --output .\rvmdk\freertos_project.bin .\rvmdk\freertos_project.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: .;..;..\..\..\..;..\..\..\..\third_party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\third_party\FreeRTOS;..\..\..\..\third_party\FreeRTOS\Source\include;..\..\..\..\third_party
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: freertos_project.sct
  link misc: --entry Reset_Handler
  group Source
    ./: freertos_project.c startup_rvmdk.S led_util.c led_blue_task.c led_green_task.c led_red_task.c task_util.c
    ../../../../third_party/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../third_party/FreeRTOS/Source/: list.c queue.c tasks.c
    ../../../../third_party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Libraries
    ../../../../driverlib/rvmdk/: driverlib.lib
  group Documentation
    ./: readme.txt
  group UART
    ./: uart_util.c
    ../../../../utils/: uartstdio.c
